# IAR project C7Detect.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __UC_AUTOBUILD_DEFAULT
  ICCARM.CCDiagSuppress: Pa039 ,Pa082
  ICCARM.CCIncludePath2: platcode\devlib\inc; platcode\devlib\std; platcode\xcanlib; platcode\xcanlib\include; platcode\FreeRTOSv10\include; platcode\FreeRTOSv10\portable\ARM_CM3; platcode\StStdPeriphDriver\inc; ..\code\devinit; ..\code\dev\inc; ..\code\FreeRTOS; ..\code\iosrc; ..\code\xcan; ..\code\app\inc; ..\code\inc; ..\code\fat; ..\code\pid; ..\code\UpdataShare; platcode; ; ..\code\version
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\code\FreeRTOS
  OBJCOPY.OOCOutputFile: C7Detect.bin
  postbuild: build_post.bat  $PROJ_DIR$ $TARGET_FNAME$
  ILINK.IlinkOutputFile: C7Detect.out
  ILINK.IlinkIcfFile: link_only_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group app
    ../code/app/source/: bootMain.c FunCtrl.c main.c MotorCtrl.c ProgramUpdata.c QRCodeMod.c SysData.c TaskMove.c TaskTempModule.c TaskWasteDetect.c
  group dev
    ../code/UpdataShare/: FlashDrive.c
    ../code/dev/source/: i2c_io.c mpu6050.c piheat_pid.c sensor.c stm32_flash.c tempfan.c thb6128.c XH711.c
    platcode/StStdPeriphDriver/src/: stm32f10x_flash.c
  group devinit
    ../code/devinit/: devinit.c startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group platlib/dev/core
    platcode/devlib/core/: adc.c bxcan.c dac.c dev.c dma.c eth.c i2c.c io.c pw.c rtc.c spi.c tim.c usart.c
  group platlib/dev/plat
    platcode/devlib/plat/: a3983.c at45.c devplat.c ds18b20.c pwm.c
  group platlib/dev/std
    platcode/devlib/std/: core_cm3.c misc.c system_stm32f10x.c
  group platlib/dev/version
    ./: ver_def.c
  group platlib/freertos
    platcode/FreeRTOSv10/: croutine.c heap_2.c list.c queue.c tasks.c
    platcode/FreeRTOSv10/portable/ARM_CM3/: port.c portasm.s
  group platlib/xcanlib
    platcode/xcanlib/: xcan.c xcan_in.c xcan_out.c xcan_sync.c
  group xcan
    ../code/xcan/: xcan_config.c
