/*******************************************************************************
文件名称：   ap3156.c
文件目录：   $PROJ_DIR$\..\code\dev\plat
项目名称：   事业一部技术平台
创建者：     陆作沛
创建日期：   20140520
程序用途：   AP3156驱动程序

版权声明：   Copyright urit Co.,Ltd.All Right Reserved

日期：20140522
第一次修改： 格式规范
修改人：     陆作沛
修改内容：   格式规范

日期：2016.04.21
修改内容：加入技术平台
修改人：胥强

*******************************************************************************/

/*******************************************************************************
Include files头文件
*******************************************************************************/
#include "devplat.h"

#if(CONFIG_AP3156)
/*******************************************************************************
Constant and Macro Definition常量以及宏定义
*******************************************************************************/

/*******************************************************************************
Global Variables Definition全局变量定义
*******************************************************************************/
static const uint16_t con_wAp3156Code[36] = {
        0,   5,  50, 10,  20,\
        36, 38,  40, 42,  45,\
        47, 50,  53, 56,  60,\
        63, 67,  71, 75,  80,\
        84, 89,  95,100, 106,\
        112,119,126,134, 142,\
        150,159,168,178, 189,200
};

/*******************************************************************************
Local Variables Definition内部全局变量定义
*******************************************************************************/

/*******************************************************************************
外部全局变量申明
*******************************************************************************/

/*******************************************************************************
内部数据结构与数据类型定义
*******************************************************************************/
static struct
{
    unsigned int *pwdSda;   //驱动器的控制引脚
    unsigned char byTimNo;

	unsigned char abySeq[6];//序列
	unsigned char bySeqNeed;//需要的序列个数
	unsigned char bySeqCnt; //序列计数
	unsigned char byCntStep;//脉冲数

	unsigned char byCnt;
	unsigned char byDelay;
	bool blIsWork;
}stAP3156;

/*******************************************************************************
内部函数申明
*******************************************************************************/
static void KernelProg(unsigned int dwPare);

/*******************************************************************************
函数功能：
*   @ 停止驱动使用的定时器,并设备非忙
参数描述：
*   @ 无
返回值描述：
*   @  0：成功
说明：
*******************************************************************************/
static int Stop(void)
{
    DevTim->Stop(stAP3156.byTimNo);
	stAP3156.blIsWork = false;

    return 0;
}

/*******************************************************************************
函数功能：
*   @ 启动定时器，并产生周期事件
参数描述：
*   @ 无
返回值描述：
*   @  0：成功
说明：
*******************************************************************************/
static int Start(void)
{
	stAP3156.blIsWork = 1;

    DevTim->TimEvent(stAP3156.byTimNo, 72 * 2 - 1, KernelProg, 0);
    return 0;
}

#if(0)
/*******************************************************************************
函数功能：
*   @ 设定驱动器的模式
参数描述：
*   @ 无
返回值描述：
*   @  unsigned char byCnt：各个模式需要的脉冲数
说明：
*******************************************************************************/
static int SetMode(unsigned char byCnt)
{
	stAP3156.bySeqNeed       = 2;       //2个状态
	stAP3156.bySeqCnt        = 0;
	stAP3156.byCnt           = 0;
	stAP3156.byCntStep       = 0;
	stAP3156.byDelay         = 0;

	stAP3156.abySeq[0]       = 8;
	stAP3156.abySeq[1]       = byCnt;  //频率模式

    stAP3156.blIsWork = true;
	Start();
    while(stAP3156.blIsWork == true) {;}
}

/*******************************************************************************
函数功能：
*   @ 设定为2ma的模式
参数描述：
*   @ 无
返回值描述：
*   @  0：成功
说明：
*******************************************************************************/
static int SetMode2MA(void)
{
	SetMode(2);
    return 0;
}

/*******************************************************************************
函数功能：
*   @ 设定为20ma的模式
参数描述：
*   @ 无
返回值描述：
*   @  0：成功
说明：
*******************************************************************************/
void SetMode20MA(void)
{
	SetMode(1);
}

/*******************************************************************************
函数功能：
*   @ 设定为25ma的模式
参数描述：
*   @ 无
返回值描述：
*   @  0：成功
说明：
*******************************************************************************/
void SetMode25MA(void)
{
	SetMode(3);
}
#endif

/*******************************************************************************
函数功能：
*   @ 设置打开灯及其电流值
参数描述：
*   @ emLedChTdf emLedCh ：通道编号
*   @ emCurLevTdf emCurLev ：使用的电流编号
*   @ bool blIsRetNow ： true:立即返回，false:等待执行完后再返回
返回值描述：
*   @  0：成功
说明：
*   @ 时间要求不高的情况下，建议等待返回，同时在中断中使用时必须立即返回。
*******************************************************************************/
static int Write(emLedChTdf emLedCh, emCurLevTdf emCurLev, bool blIsRetNow)
{
	if(emCurLev > ApCurLev5) {
		stAP3156.bySeqNeed       = 6;    //4个状态
		stAP3156.bySeqCnt        = 0;
		stAP3156.byCnt           = 0;
		stAP3156.byCntStep       = 0;
		stAP3156.byDelay         = 0;

		stAP3156.abySeq[0] = 9;
		stAP3156.abySeq[1] = 2;
		stAP3156.abySeq[2] = 10;
		stAP3156.abySeq[3] = 5;
		stAP3156.abySeq[4] = emLedCh;
		stAP3156.abySeq[5] = emCurLev - ApCurLev5;
	}
	else {
		stAP3156.bySeqNeed       = 3;    //4个状态
		stAP3156.bySeqCnt        = 0;
		stAP3156.byCnt           = 0;
		stAP3156.byCntStep       = 0;
		stAP3156.byDelay         = 0;

		stAP3156.abySeq[0] = 33;
		stAP3156.abySeq[1] = emLedCh;
		stAP3156.abySeq[2] = emCurLev;
	}

	Start();
	if(blIsRetNow == true) return 0;

	while(stAP3156.blIsWork == true) {;}
	for(int i = 0;i<0xfff;i++){;}
    return 0;
}

/*******************************************************************************
函数功能：
*   @ 使用电流等级，返回实际的电流值
参数描述：
*   @ emCurLevTdf emCurLev：电流等级
返回值描述：
*   @  -1：失败
*   @  实际的电流值*10
说明：
*   @ 返回实际的电流值时，其值*10.
*******************************************************************************/
static int GetCurrent(emCurLevTdf emCurLev)
{
    unsigned char bySn = ApCurLev0 - emCurLev;

    if(emCurLev > 35) return -1;
    return con_wAp3156Code[bySn];
}

/*******************************************************************************
函数功能：
*   @ 使用定时器产生序列，此函数被定时器中断调用
参数描述：
*   @ unsigned int dwPare：未使用
返回值描述：
*   @  无
说明：
*******************************************************************************/
static void KernelProg(unsigned int dwPare)
{
	if(stAP3156.byDelay != 0) {
		stAP3156.byDelay --;
		return;
	}

	if((stAP3156.byCnt % 2) == 0) *stAP3156.pwdSda = 0;
	else {
		*stAP3156.pwdSda = 1;
		stAP3156.byCntStep ++;

		if(stAP3156.byCntStep == stAP3156.abySeq[stAP3156.bySeqCnt]) {
			stAP3156.bySeqCnt ++;
			stAP3156.byCntStep = 0;
			stAP3156.byDelay = 100;
		}

		if(stAP3156.bySeqCnt == stAP3156.bySeqNeed) Stop();
	}

	stAP3156.byCnt ++;
}

static const DevAp3156Tdf s_Dev = {
    Write,
    GetCurrent,
};

/*******************************************************************************
函数功能：
*   @ ap3156初始化
参数描述：
*   @ 初始化参数
返回值描述：
*   @ 方法合集
说明：
*******************************************************************************/
const DevAp3156Tdf *Ap3156Init(Ap3156InitTdf *pstInit)
{
    memset(&stAP3156,0,sizeof(stAP3156));

    stAP3156.pwdSda = pstInit->pwdSda;
    stAP3156.byTimNo = pstInit->byTimNo;

    DevTim->Config(stAP3156.byTimNo, 1, 72 * 2 - 1);

    //以下代码是进行驱动器复位
    *stAP3156.pwdSda = 1;
    for(__IO int i = 0;i<0xfff;i++){;}
    *stAP3156.pwdSda = 0;
    for(__IO int i = 0;i<0xfffff;i++){;}
    *stAP3156.pwdSda = 1;

    for(__IO int i = 0;i<0x1ffff;i++){;}


    Write(ApLedChAll, ApCurLev0, 0);//关闭所有灯

    return &s_Dev;
}

#endif