/*******************************************************************************
文件名称：   ad9822.c
目录：       PROJ_DIR$/../code/dev
项目名称：   URIT-1550全自动尿液分析仪
创建者：     XQSCU
创建日期：   20120810
程序用途：   用于ad9822驱动程序

版权声明：
Copyright urit Co.,Ltd.
All Right Reserved

修改及维护信息
20120810：
第一次由XQ创建初始程序。

*******************************************************************************/

/*******************************************************************************
Include file
*******************************************************************************/
#include "devplat.h"

#if(CONFIG_AD9822)
/*******************************************************************************
Constant and Macro Definition 常量以及宏定义
*******************************************************************************/
#define AD_DELAY        for(volatile unsigned int ij = 0; ij < 0x0a; ij ++){;}

/*******************************************************************************
全局变量定义
*******************************************************************************/

/*******************************************************************************
外部变量定义
*******************************************************************************/

/*******************************************************************************
数据结构与数据类型定义
*******************************************************************************/

/*******************************************************************************
内部全局变量申明
*******************************************************************************/
static Ad9822InitTdf s_Dev9822;

/*******************************************************************************
函数功能：
*   @ 向ad9822写入数据
参数描述：
*   @ unsigned short int ： 需要写入的数据
返回值描述：
*   @ 无
说明：
*   @ 无
*******************************************************************************/
static void Write(unsigned short int wInDat)
{
    unsigned char byDat;

    DevIo->Write(s_Dev9822.byEnIoSn, s_Dev9822.byEnPin, 1);
    DevIo->Write(s_Dev9822.byEnIoSn, s_Dev9822.byEnPin, 0);
    DevIo->Write(s_Dev9822.byClkIoSn, s_Dev9822.byClkPin, 0);

    for(volatile unsigned int i = 0;i < 16;i ++) {
        if((wInDat & 0x8000) == 0x8000) byDat = 1;
        else byDat = 0;

        DevIo->Write(s_Dev9822.bySdaIoSn, s_Dev9822.bySdaPin, byDat);
        AD_DELAY;
        DevIo->Write(s_Dev9822.byClkIoSn, s_Dev9822.byClkPin, 1);
        AD_DELAY;
        DevIo->Write(s_Dev9822.byClkIoSn, s_Dev9822.byClkPin, 0);
        wInDat <<= 1;
    }

    DevIo->Write(s_Dev9822.byClkIoSn, s_Dev9822.byClkPin, 0);
    DevIo->Write(s_Dev9822.byEnIoSn, s_Dev9822.byEnPin, 1);
}

static const DevAd9822Tdf s_Dev = {
    Write,
};

/*******************************************************************************
函数功能：
*   @ 初始化ad9822
参数描述：
*   @ 初始化参数
返回值描述：
*   @ 操作集合
说明：
*   @ 无
*******************************************************************************/
const DevAd9822Tdf *Ad9822Init( Ad9822InitTdf *pstInit)
{
    if(!pstInit) return 0;

    s_Dev9822 = *pstInit;
    DevIo->Write(s_Dev9822.byEnIoSn, s_Dev9822.byEnPin, 1);
    return &s_Dev;
}
#endif