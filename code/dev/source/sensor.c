/*****************************************************************************
文件名称：sensor.c
文件目录：$PROJ_DIR$/usr/dev/source
项目名称：
创建者：
创建日期：
程序用途：
版权声明：Copyright urit Co.,Ltd.All Right Reserved

log:

******************************************************************************/

/******************************************************************************
Include files头文件
******************************************************************************/
#include "devinit.h"
#include "sensor.h"
#include "MotorCtrl.h"
/******************************************************************************
Constant and Macro Definition常量以及宏定义
******************************************************************************/

/******************************************************************************
Global Variables Definition全局变量定义
******************************************************************************/

/******************************************************************************
外部全局变量申明
******************************************************************************/

/******************************************************************************
内部数据结构与数据类型定义
******************************************************************************/


/******************************************************************************
内部全局变量定义
******************************************************************************/


/******************************************************************************
内部函数申明
******************************************************************************/

/*****************************************************************************
函数名：void Init(void)
函数功能：光耦硬件初始化
参数描述:
返回值描述：
特殊算法：
注意事项：
******************************************************************************/
static void Init(void)
{
    DevIo->RemapConfig(GPIO_Remap_SWJ_JTAGDisable,ENABLE);
    DevIo->Config(PD, 4, 1, Mode_IN_FLOATING);//401光耦  滴镜油位有无试纸卡 J15
    DevIo->Config(PD, 2, 1, Mode_IN_FLOATING);//401光耦 检测有无载玻片//J25
    DevIo->Config(PD, 6, 1, Mode_IPD);//行程开关，用于检测试纸盒有无，配置下拉输入，高电平有效 载玻片盒子 J18
    DevIo->Config(PD, 3, 1, Mode_IN_FLOATING);//染剂位有无试纸卡 J21
    //DevIo->Config(PB, 1, 1, Mode_IN_FLOATING);//镜油检测光耦
    DevIo->Config(PD, 8, 1, Mode_IN_FLOATING);//镜油检测光耦5
    DevIo->Config(PD, 5, 1, Mode_IN_FLOATING);//镜油检测光耦5
}

/*****************************************************************************
函数名：void GetSensor(void)
函数功能：获取判断光耦状态
参数描述:dwHwnd 0-1
返回值描述：
特殊算法：
注意事项：
******************************************************************************/
uint8_t GetSensor(uint16_t *pData)
{
    MotorCtrl.GetOp(pData);
    return 0;
}

/*****************************************************************************
函数名：void GetSlidBoxSta(void)
函数功能：获取判断载玻片盒子光耦状态
参数描述:dwHwnd 0-1
返回值描述：
特殊算法：
注意事项：
******************************************************************************/
uint8_t GetSlidBoxSta(void)
{
    if(DevIo->Read(PD,6) == 0)//新电路板  J18
    {
        for(__IO int i = 0;i<0xffff; i++);
        for(__IO int i = 0;i<0xffff; i++);
        for(__IO int i = 0;i<0xffff; i++);
        if(DevIo->Read(PD,6) == 0)
        {
            return 1;
        }
    }
    return 0;
}

/*****************************************************************************
函数名：void GetSlidBoxSta(void)
函数功能：获取镜油状态
参数描述:dwHwnd 0-1
返回值描述：
特殊算法：
注意事项：
******************************************************************************/
uint8_t CheckOilSta(void)
{
   //return DevIo->Read(PB,1);
      return DevIo->Read(PD,8);//DevIo->Read(PD,8);DevIo->Read(PD,5)
}

const OpSensorTdf OpSensor = {
    Init,
    GetSensor,
    GetSlidBoxSta,
    CheckOilSta,
};

