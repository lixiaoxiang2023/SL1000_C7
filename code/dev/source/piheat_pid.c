/*******************************************************************************
文件名称：   piheat_pid.c
目录：       $PROJ_DIR$/../code/USER/APP
项目名称：
创建者：
创建日期：   20200409
程序用途：   pid 底层算法库

版权声明：
Copyright urit Co.,Ltd.
All Right Reserved

修改及维护信息

*******************************************************************************/

/*******************************************************************************
Include file
*******************************************************************************/
#include "piheat_pid.h"
#include <math.h>
/*******************************************************************************
常量定义
*******************************************************************************/

/*******************************************************************************
内部函数声明
*******************************************************************************/


/*******************************************************************************
全局变量定义
*******************************************************************************/

/*******************************************************************************
数据结构与数据类型定义
*******************************************************************************/

/*******************************************************************************
内部全局变量申明
*******************************************************************************/

/*******************************************************************************
函数定义
*******************************************************************************/

/*******************************************************************************
函数功能：
*   @ 计算pid参数
参数描述：
*   @ stPidTdf *pstPid： PID调节参数
*   @ float Temin：传感器实际值
*   @ 返回值：实际值
返回值描述：
*   @ 无
说明：
*   @ PID的位置型公式：Temset=370;Kp=2;Ki=7;Kd=7;
*   @
*   @ 本函数只提供 调节算法，但不提供执行方法
********************************************************************************/
float PidLoc(stPidTdf *pstPid)
{
  if(!pstPid) return 0;
  if(pstPid->Temset == 0) return 0;

  pstPid->dev = (pstPid->Temset - pstPid->Temin)/10;//比例

  pstPid->dev_sum += pstPid->dev;    //累计误差

  pstPid->fout = pstPid->Kp * pstPid->dev + (pstPid->Ki * pstPid->dev_sum) + pstPid->Kd * (pstPid->dev_last - pstPid->dev)+10;//8 pstPid->dev - pstPid->dev_last 4

  pstPid->dev_last = pstPid->dev;
  if(isnan(pstPid->dev_sum)) pstPid->dev_sum = 0;
  if(pstPid->fout > 300) pstPid->dev_sum = 300;
  return pstPid->fout;
}

/*******************************************************************************
函数功能：
*   @ 计算pid参数
参数描述：
*   @ stPidTdf *pstPid： PID调节参数
*   @ float Temin：传感器实际值
*   @ 返回值：实际值
返回值描述：
*   @ 无
说明：
*   @ PID的位置型公式：Temset=370;Kp=2;Ki=7;Kd=7;
*   @
*   @ 本函数只提供 调节算法，但不提供执行方法
********************************************************************************/
float PidLocFan(stPidTdf *pstPid)
{
  if(!pstPid) return 0;
  if(pstPid->Temset == 0) return 0;
  pstPid->dev = (pstPid->Temset - pstPid->Temin)/10;//比例

  pstPid->dev_sum += pstPid->dev;    //累计误差

  pstPid->fout = pstPid->Kp * pstPid->dev + (pstPid->Ki * pstPid->dev_sum) + pstPid->Kd * (pstPid->dev_last - pstPid->dev)+5;//8 pstPid->dev - pstPid->dev_last 4

  pstPid->dev_last = pstPid->dev;
  if(isnan(pstPid->dev_sum)) pstPid->dev_sum = 0;
  if(pstPid->fout > 300) pstPid->dev_sum = 300;
  
  return pstPid->fout;
}