/*****************************************************************************************
文件名称：SysData.c
目录：$PROJ_DIR$/../code/app
项目名称：
创建者：
创建日期：
程序用途：
系统参数管理

版权声明：
Copyright urit Co.,Ltd.
All Right Reserved

修改及维护信息

*****************************************************************************************/

/*****************************************************************************************
Include file
*****************************************************************************************/
#include "devinit.h"
#include "flash.h"
//#include "ff.h"
#include "SysData.h"
#include "iosrc.h"
#include "system_stm32f10x.h"
#include "stm32_flash.h"

/*****************************************************************************************
常量或宏定义
*****************************************************************************************/
//const stC7SysPareTypeDef  con_stC7SysPareInit = {
//    1,     //系统参数版本号
//    TRUE,
//    6000,  //M1电机从复位试纸盒位置到滴样位，电机所走的步数
//    6800,  //M1电机从滴样位置到加热位，电机所走的步数
//    40,    //M2电机拨动玻片一次所走步数，电机所走的步数
//    2,     //镜油滴数
//    6000,
//    1000,    //M3下降到冲洗位置
//    9000,
//    9000,
//    0,      //去皮
//    700,    //M3下降到吹风位置
//    650,    //固化温度
//    750,    //烘干温度
//};
const stC7SysPareTypeDef  con_stC7SysPareInit = {
    1,     //系统参数版本号
    TRUE,
    4900,  //M1电机从复位试纸盒位置到滴样位，电机所走的步数
    8300,  //M1电机从滴样位置到加热位，电机所走的步数
    40,    //M2电机拨动玻片一次所走步数，电机所走的步数
    2,     //镜油滴数
    4950,
    300,    //M3下降到冲洗位置
    9000,
    9000,
    0,      //去皮
    700,    //M3下降到吹风位置
    650,    //固化温度
    750,    //烘干温度
    120,    //M4电机调试步数
    600,    //M2电机走一小步步数
};
/*****************************************************************************************
内部全局变量申明
*****************************************************************************************/
static stC7SysPareTypeDef       s_stC7SysPare;
static stC7SysPareTypeDef       s_stC7SysTempPare;//系统临时参数

/*****************************************************************************************
全局变量定义
*****************************************************************************************/
stC7SysPareTypeDef        *g_pstC7SysPare = &s_stC7SysPare;
stC7SysPareTypeDef        *g_pstC7SysTempPare = &s_stC7SysTempPare;
/*****************************************************************************************
数据结构与数据类型定义
*****************************************************************************************/

/*****************************************************************************************
外部变量声明
*****************************************************************************************/
//extern FATFS g_stFs;    // 逻辑驱动器的工作区(文件系统对象)
//extern FIL g_stFile;      // 文件对象

/*****************************************************************************************
内部函数申明
*****************************************************************************************/

/*****************************************************************************************
函数名：uint8_t SysDatainit(void)
参数描述：
无
返回值描述：无
说明：
系统参数初始化

特殊算法：
注意事项：
*****************************************************************************************/
uint8_t SysDatainit(void)
{
    static uint8_t byMark = 0;

    memset(g_pstC7SysPare, 0, sizeof(stC7SysPareTypeDef));
    s_stC7SysPare = con_stC7SysPareInit;
    __set_PRIMASK(1);
    if(!CheckSaveFlashData(SYS_DATA_OFFEST) || (byMark == 1))//检查是否存储有系统参数
    {//无数据写入默认参数
        s_stC7SysPare = con_stC7SysPareInit;
        UserDataToFlash(SYS_DATA_OFFEST, (u8 *)g_pstC7SysPare, sizeof(stC7SysPareTypeDef));//写入默认系统参数

    }
    else
    {//有数据则读出
       FlashToUserData(SYS_DATA_OFFEST, (u8 *)g_pstC7SysPare, sizeof(stC7SysPareTypeDef));
    }
    //拷贝到临时参数
    memset(g_pstC7SysTempPare, 0, sizeof(stC7SysPareTypeDef));
    memcpy(g_pstC7SysTempPare, g_pstC7SysPare, sizeof(stC7SysPareTypeDef));//将系统参数拷贝到临时参数
    __set_PRIMASK(0);
    return byMark;
}

/*****************************************************************************************
函数名：void SaveSysData(void)
参数描述：
无
返回值描述：无
说明：
保存系统参数

特殊算法：
注意事项：
*****************************************************************************************/
void SaveSysData(void)
{
    uint8_t byErr;
    uint8_t byErrCounter = 0;
    g_pstC7SysPare->bInitPar = FALSE;
    do
    {
        byErr = UserDataToFlash(SYS_DATA_OFFEST, (void*)g_pstC7SysPare, sizeof(stC7SysPareTypeDef));
        byErrCounter++;
        __set_PRIMASK(0);
    }while((!byErr) && (byErrCounter <= 3));

    if(byErrCounter > 3)
    {

    }
}
